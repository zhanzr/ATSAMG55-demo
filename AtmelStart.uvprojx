# Keil uVision project AtmelStart.uvprojx, settings and files
target ATSAMG55J19 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAMG55J19 Microchip
  pack: Keil.SAMG_DFP.1.2.0
  cpu: IRAM(0x20000000,0x28000) IROM(0x00400000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AtmelStart
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __SAMG55J19__
  c include: .\samg55\include;.\CMSIS\Core\Include
  memory RVCT4: ROM 0x400000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
software components: Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, Device:Startup 1.0.0
